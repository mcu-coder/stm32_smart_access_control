# Keil uVision project LED.uvprojx, settings and files
target KEY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: key +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TASK\git;..\TASK\task;..\TASK\timer;..\NET\device;..\NET\Json;..\NET\mqtt;..\NET\onenet;..\NET\massage;..\HARDWARE\ADXL345;..\HARDWARE\KEY;..\HARDWARE\OLED-SPI;..\HARDWARE\LED;..\HARDWARE\USART2;..\HARDWARE\STMFLASH;..\HARDWARE\DHT11;..\HARDWARE\ADC;..\HARDWARE\RELAY;..\HARDWARE\LEVEL;..\HARDWARE\SG90;..\HARDWARE\TTP229;..\HARDWARE\RC522;..\HARDWARE\AS608
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED-SPI/: oled.c
    ../HARDWARE/STMFLASH/: flash.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/USART2/: face.c usart2.c
    ../HARDWARE/SG90/: sg90.c
    ../HARDWARE/TTP229/: TTP229.c
    ../HARDWARE/AS608/: AS608.c usart4.c rc522.c
    ../HARDWARE/LEVEL/: level.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_dma.c
  group README
    ../: README.TXT
  group NET
    ../NET/device/: esp8266.c
    ../NET/Json/: cJSON.c
    ../NET/mqtt/: MqttKit.c
    ../NET/onenet/: aly.c
  group TASK
    ../TASK/git/: git.c
    ../TASK/task/: task.c
    ../TASK/timer/: timer.c
